# Keil uVision project LCD.uvprojx, settings and files
target LCD (ARM-ADS)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD;..\Config;..\GUI\LCDDriver;..\HARDWARE\TIMER;..\GUI\GUI_H
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f030.s
  group FWLIB
    ../FWLIB/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_misc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LCD/: ili7735r.c
    ../HARDWARE/TIMER/: timer.c
  group GUI_Config
    ../Config/: GUI_X.c GUIConf.h GUITouchConf.h LCDConf.h
  group GUI_LCDDriver
    ../GUI/LCDDriver/: LCDDummy.c LCDNull.c LCDWin.c
  group LIB
    ../OBJ/: LCD.lib
